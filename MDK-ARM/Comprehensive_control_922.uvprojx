# Keil uVision project Comprehensive_control_922.uvprojx, settings and files
target Comprehensive_control_922 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: comprehensive23_7_10_18_31 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\RL-ARM\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c bsp.c stm32f4xx_hal_timebase_tim.c bsp_dwt.c bsp_can.c udp_echoserver.c bsp_gpio.c bsp_uart_fifo.c bsp_timer.c bsp_ds18b20.c bsp_uart.c bsp_dma.c bsp_i2c.c bsp_gps.c bsp_tim_pwm.c bsp_led.c bsp_adc.c bsp_task.c bsp_task_pccommun.c bsp_task_rk3588commun.c bsp_rk3588_shutdown.c bsp_fanspeed.c
    ../Core/Inc/: includes.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RL_ARM
    ../RL-ARM/Driver/: ETH_INIT.c ethernetif.c EMAC_STM32F4xx.h EMAC_STM32F4xx.c
  group APP
    ../Core/Src/: app_lwip_lib.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 2.10, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3, Network:API 2.2.0, Network:CORE 2.2.0, Network:Driver:Ethernet 2.2.0, Network:Interface:Ethernet 2.2.0, Network:RTOS 2.2.0
